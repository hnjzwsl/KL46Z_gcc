# IAR project host_msd_fatfs_bm.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL46Z256xxx4 NXP MKL46Z256xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; _DEBUG=1; CPU_MKL46Z256VLL4; USB_STACK_BM; PRINTF_ADVANCED_ENABLE=1
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ..; ../../../../../../middleware/fatfs/source; ../../../..; ../../../../../../CMSIS/Include; ../../../../../../middleware/usb; ../../../../../../middleware/usb/osa; ../../../../../../middleware/usb/include; ../../../../../../middleware/usb/host; ../../../../../../devices/MKL46Z4/drivers; ../../../../../../middleware/usb/host/class; ../../../../../../devices/MKL46Z4/utilities/io; ../../../../../../devices/MKL46Z4/utilities/str; ../../../../../../devices/MKL46Z4/utilities/log; ../../../../../../devices/MKL46Z4/utilities; ../../../../../../devices/MKL46Z4
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: host_msd_fatfs_bm.out
  ILINK.IlinkIcfFile: MKL46Z256xxx4_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; _DEBUG=0; CPU_MKL46Z256VLL4; USB_STACK_BM; PRINTF_ADVANCED_ENABLE=1
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
  group doc
    ../: readme.txt
  group sources
    ../: app.h app.c host_msd_fatfs.c ffconf.h host_msd_fatfs.h usb_host_config.h fsl_usb_disk.h fsl_usb_disk_bm.c
  group board/src
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group usb/host
    ../../../../../../middleware/usb/host/: usb_host_khci.c usb_host_khci.h usb_host.h usb_host_hci.c usb_host_hci.h usb_host_devices.c usb_host_devices.h usb_host_framework.h usb_host_framework.c
  group usb/host/class
    ../../../../../../middleware/usb/host/class/: usb_host_hub.c usb_host_hub.h usb_host_hub_app.c usb_host_hub_app.h usb_host_msd.c usb_host_msd.h usb_host_msd_ufi.c
  group usb/include
    ../../../../../../middleware/usb/include/: usb.h usb_misc.h usb_spec.h
  group osa
    ../../../../../../middleware/usb/osa/: usb_osa.h usb_osa_bm.h usb_osa_bm.c
  group drivers
    ../../../../../../devices/MKL46Z4/drivers/: fsl_port.h fsl_common.h fsl_common.c fsl_clock.h fsl_clock.c fsl_sim.h fsl_sim.c fsl_smc.h fsl_smc.c fsl_ftfx_adapter.h fsl_ftfx_utilities.h fsl_ftfx_features.h fsl_ftfx_controller.c fsl_ftfx_controller.h fsl_ftfx_flash.c fsl_ftfx_flash.h fsl_ftfx_cache.c fsl_ftfx_cache.h fsl_ftfx_flexnvm.c fsl_ftfx_flexnvm.h fsl_flash.h fsl_lpsci.h fsl_lpsci.c fsl_uart.h fsl_uart.c fsl_gpio.h fsl_gpio.c
  group fatfs/fatfs_source
    ../../../../../../middleware/fatfs/source/: diskio.c ff.c ffsystem.c ffunicode.c
  group fatfs/fatfs_include
    ../../../../../../middleware/fatfs/source/: diskio.h ff.h integer.h
  group utilities
    ../../../../../../devices/MKL46Z4/utilities/io/: fsl_io.c fsl_io.h
    ../../../../../../devices/MKL46Z4/utilities/log/: fsl_log.c fsl_log.h
    ../../../../../../devices/MKL46Z4/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/MKL46Z4/utilities/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_assert.c
  group startup
    ../../../../../../devices/MKL46Z4/: system_MKL46Z4.c system_MKL46Z4.h
    ../../../../../../devices/MKL46Z4/iar/: startup_MKL46Z4.s
