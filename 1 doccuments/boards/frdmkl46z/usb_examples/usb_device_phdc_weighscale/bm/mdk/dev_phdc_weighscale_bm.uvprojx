# Keil uVision project dev_phdc_weighscale_bm.uvprojx, settings and files
target dev_phdc_weighscale_bm debug (ARM-ADS)
  device: MKL46Z256VLL4 NXP
  cpu: CPUTYPE("Cortex-M0+")
  output: dev_phdc_weighscale_bm.out
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: DEBUG, _DEBUG=1, CPU_MKL46Z256VLL4, USB_STACK_BM
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ..;../../../..;../../../../../../CMSIS/Include;../../../../../../middleware/usb;../../../../../../middleware/usb/osa;../../../../../../middleware/usb/include;../../../../../../middleware/usb/device;../../../../../../devices/MKL46Z4/drivers;../../../../../../devices/MKL46Z4/utilities/io;../../../../../../devices/MKL46Z4/utilities/str;../../../../../../devices/MKL46Z4/utilities/log;../../../../../../devices/MKL46Z4/utilities;../../../../../../devices/MKL46Z4
  asm define: DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x6000
  scatter file: MKL46Z256xxx4_flash.scf
  link misc: --remove
  group doc
    ../: readme.txt
  group sources-ieee11073_agent
    ../: ieee11073_agent.c ieee11073_agent.h ieee11073_types.h ieee11073_timer.c ieee11073_timer.h
  group sources
    ../: usb_device_descriptor.c usb_device_descriptor.h usb_shim_agent.c usb_shim_agent.h weighscale.c weighscale.h usb_device_config.h
  group board-src
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group usb-device-source-khci
    ../../../../../../middleware/usb/device/: usb_device_khci.c usb_device_khci.h
    ../../../../../../middleware/usb/include/: usb_khci.h
  group usb-include
    ../../../../../../middleware/usb/include/: usb.h usb_misc.h usb_spec.h
  group osa
    ../../../../../../middleware/usb/osa/: usb_osa.h usb_osa_bm.h usb_osa_bm.c
  group usb-device-include
    ../../../../../../middleware/usb/device/: usb_device.h
  group usb-device-source
    ../../../../../../middleware/usb/device/: usb_device_dci.c usb_device_dci.h
    ../: usb_device_ch9.c usb_device_ch9.h
  group drivers
    ../../../../../../devices/MKL46Z4/drivers/: fsl_port.h fsl_common.h fsl_common.c fsl_clock.h fsl_clock.c fsl_sim.h fsl_sim.c fsl_smc.h fsl_smc.c fsl_ftfx_adapter.h fsl_ftfx_utilities.h fsl_ftfx_features.h fsl_ftfx_controller.c fsl_ftfx_controller.h fsl_ftfx_flash.c fsl_ftfx_flash.h fsl_ftfx_cache.c fsl_ftfx_cache.h fsl_ftfx_flexnvm.c fsl_ftfx_flexnvm.h fsl_flash.h fsl_lpsci.h fsl_lpsci.c fsl_uart.h fsl_uart.c fsl_gpio.h fsl_gpio.c
  group usb-device-class
    ../: usb_device_class.c usb_device_class.h
  group usb-device-class-phdc
    ../: usb_device_phdc.c usb_device_phdc.h
  group utilities
    ../../../../../../devices/MKL46Z4/utilities/io/: fsl_io.c fsl_io.h
    ../../../../../../devices/MKL46Z4/utilities/log/: fsl_log.c fsl_log.h
    ../../../../../../devices/MKL46Z4/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/MKL46Z4/utilities/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_assert.c
  group startup
    ../../../../../../devices/MKL46Z4/: system_MKL46Z4.c system_MKL46Z4.h
    ../../../../../../devices/MKL46Z4/arm/: startup_MKL46Z4.s
target dev_phdc_weighscale_bm release (ARM-ADS)
  device: MKL46Z256VLL4 NXP
  cpu: CPUTYPE("Cortex-M0+")
  output: dev_phdc_weighscale_bm.out
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: NDEBUG, _DEBUG=0, CPU_MKL46Z256VLL4, USB_STACK_BM
  c misc: as above
  c include: as above
  asm define: NDEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x6000
  scatter file: MKL46Z256xxx4_flash.scf
  link misc: --remove
