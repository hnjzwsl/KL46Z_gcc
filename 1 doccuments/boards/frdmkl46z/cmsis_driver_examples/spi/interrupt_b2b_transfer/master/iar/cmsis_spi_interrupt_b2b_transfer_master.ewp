# IAR project cmsis_spi_interrupt_b2b_transfer_master.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL46Z256xxx4 NXP MKL46Z256xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; CPU_MKL46Z256VLL4; FRDM_KL46Z; FREEDOM
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ..; ../../../../../../../CMSIS/Driver/Include; ../../../../..; ../../../../../../../CMSIS/Include; ../../../../../../../devices; ../../../../../../../devices/MKL46Z4/drivers; ../../../../../../../devices/MKL46Z4/cmsis_drivers; ../../../../../../../devices/MKL46Z4; ../../../../../../../devices/MKL46Z4/utilities/io; ../../../../../../../devices/MKL46Z4/utilities/str; ../../../../../../../devices/MKL46Z4/utilities/log; ../../../../../../../devices/MKL46Z4/utilities
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: cmsis_spi_interrupt_b2b_transfer_master.out
  ILINK.IlinkIcfFile: MKL46Z256xxx4_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKL46Z256VLL4; FRDM_KL46Z; FREEDOM
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
  group source
    ../: cmsis_spi_interrupt_b2b_transfer_master.c
  group board
    ../: pin_mux.c pin_mux.h RTE_Device.h
  group board/src
    ../: board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../../devices/MKL46Z4/drivers/: fsl_port.h fsl_common.h fsl_common.c fsl_clock.h fsl_clock.c fsl_gpio.h fsl_gpio.c fsl_dma.h fsl_dma.c fsl_dmamux.h fsl_dmamux.c fsl_spi.h fsl_spi.c fsl_spi_dma.h fsl_spi_dma.c fsl_ftfx_adapter.h fsl_ftfx_utilities.h fsl_ftfx_features.h fsl_ftfx_controller.c fsl_ftfx_controller.h fsl_ftfx_flash.c fsl_ftfx_flash.h fsl_ftfx_cache.c fsl_ftfx_cache.h fsl_ftfx_flexnvm.c fsl_ftfx_flexnvm.h fsl_flash.h fsl_lpsci.h fsl_lpsci.c fsl_uart.h fsl_uart.c fsl_smc.h fsl_smc.c
    ../../../../../../../devices/MKL46Z4/cmsis_drivers/: fsl_spi_cmsis.h fsl_spi_cmsis.c
  group startup
    ../../../../../../../devices/MKL46Z4/: system_MKL46Z4.c system_MKL46Z4.h
    ../../../../../../../devices/MKL46Z4/iar/: startup_MKL46Z4.s
  group utilities
    ../../../../../../../devices/MKL46Z4/utilities/io/: fsl_io.c fsl_io.h
    ../../../../../../../devices/MKL46Z4/utilities/log/: fsl_log.c fsl_log.h
    ../../../../../../../devices/MKL46Z4/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../../devices/MKL46Z4/utilities/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_assert.c
