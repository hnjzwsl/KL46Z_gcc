# Keil uVision project hello_world_virtual_com.uvprojx, settings and files
target hello_world_virtual_com debug (ARM-ADS)
  device: MKL46Z256VLL4 NXP
  cpu: CPUTYPE("Cortex-M0+")
  output: hello_world_virtual_com.out
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: DEBUG, CPU_MKL46Z256VLL4, FRDM_KL46Z, FREEDOM, PRINTF_FLOAT_ENABLE=0, SCANF_FLOAT_ENABLE=0, PRINTF_ADVANCED_ENABLE=0, SCANF_ADVANCED_ENABLE=0, USB_STACK_BM, BOARD_USE_VIRTUALCOM=1
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ../../../../../CMSIS/Include;../../../../../devices;..;../../..;../../../../../middleware/usb/device;../../../../../middleware/usb/include;../../../../../middleware/usb/osa;../../../../../devices/MKL46Z4/drivers;../../../../../devices/MKL46Z4;../../../../../devices/MKL46Z4/utilities/io;../../../../../devices/MKL46Z4/utilities/str;../../../../../devices/MKL46Z4/utilities/log;../../../../../devices/MKL46Z4/utilities
  asm define: DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x6000
  scatter file: MKL46Z256xxx4_flash.scf
  link misc: --remove
  group source
    ../: hello_world.c
  group board-src
    ../: board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group usb-device-source-khci
    ../../../../../middleware/usb/device/: usb_device_khci.c usb_device_khci.h
    ../../../../../middleware/usb/include/: usb_khci.h
  group usb-include
    ../../../../../middleware/usb/include/: usb.h usb_misc.h usb_spec.h
  group osa
    ../../../../../middleware/usb/osa/: usb_osa.h usb_osa_bm.h usb_osa_bm.c
  group drivers
    ../../../../../devices/MKL46Z4/drivers/: fsl_clock.h fsl_clock.c fsl_ftfx_adapter.h fsl_ftfx_utilities.h fsl_ftfx_features.h fsl_ftfx_controller.c fsl_ftfx_controller.h fsl_ftfx_flash.c fsl_ftfx_flash.h fsl_ftfx_cache.c fsl_ftfx_cache.h fsl_ftfx_flexnvm.c fsl_ftfx_flexnvm.h fsl_flash.h fsl_common.h fsl_common.c fsl_lpsci.h fsl_lpsci.c fsl_uart.h fsl_uart.c fsl_port.h fsl_smc.h fsl_smc.c fsl_gpio.h fsl_gpio.c
  group startup
    ../../../../../devices/MKL46Z4/: system_MKL46Z4.c system_MKL46Z4.h
    ../../../../../devices/MKL46Z4/arm/: startup_MKL46Z4.s
  group utilities
    ../../../../../devices/MKL46Z4/utilities/io/: fsl_io.c fsl_io.h
    ../../../../../devices/MKL46Z4/utilities/log/: fsl_log.c fsl_log.h
    ../../../../../devices/MKL46Z4/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MKL46Z4/utilities/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_assert.c virtual_com.c virtual_com.h usb_device_descriptor.c usb_device_descriptor.h usb_device_cdc_acm.c usb_device_cdc_acm.h usb_device_ch9.c usb_device_ch9.h usb_device_config.h
  group usb-device-include
    ../../../../../middleware/usb/device/: usb_device.h
  group usb-device-source
    ../../../../../middleware/usb/device/: usb_device_dci.c usb_device_dci.h
target hello_world_virtual_com release (ARM-ADS)
  device: MKL46Z256VLL4 NXP
  cpu: CPUTYPE("Cortex-M0+")
  output: hello_world_virtual_com.out
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: NDEBUG, CPU_MKL46Z256VLL4, FRDM_KL46Z, FREEDOM, PRINTF_FLOAT_ENABLE=0, SCANF_FLOAT_ENABLE=0, PRINTF_ADVANCED_ENABLE=0, SCANF_ADVANCED_ENABLE=0, USB_STACK_BM, BOARD_USE_VIRTUALCOM=1
  c misc: as above
  c include: as above
  asm define: NDEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x6000
  scatter file: MKL46Z256xxx4_flash.scf
  link misc: --remove
